options:
  parameters:
    author: AA, AV, OW
    generate_options: qt_gui
    id: AC
    output_language: python
    title: Acoustic Communication
  states: {}

blocks:
- name: EbN0_dB
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '250'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sig_pwr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '50'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-1'
    reference: '1.0'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {state: disabled}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*deviation/samp_rate
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: math.sqrt( sig_pwr/ (10**(EbN0_dB/10)) * samp_rate/symbol_rate )
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: fc-deviation
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: fc+deviation
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: '"Speakers (2- Realtek(R) Audio)"'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"Elgato Wave:3"'
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate/symbol_rate)
    max_iter: '4000'
    scale: 0.2*symbol_rate/samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate/symbol_rate)
    max_iter: '4000'
    scale: 0.2*symbol_rate/samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/symbol_rate)
    type: float
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/symbol_rate)
    type: float
  states: {state: disabled}
- name: blocks_repeat_1_1
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/symbol_rate)
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[1,0,1,0,0,0,0,0,0,0,0,0,0,1,0,1,0,0,0,1,1,1]'
  states: {state: disabled}
- name: channels_channel_model2_0
  id: channels_channel_model2
  parameters:
    epsilon: '1.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1'
    freq_offset: '0.0'
    noise_voltage: 0*math.sqrt( sig_pwr/ (10**(EbN0_dB/10)) * samp_rate/symbol_rate )
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: channels_channel_model_1
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: '20'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: byte
  states: {state: disabled}
- name: digital_packet_headergenerator_bb_default_0
  id: digital_packet_headergenerator_bb_default
  parameters:
    header_len: '5'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: int(samp_rate/symbol_rate)
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport collections\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, start_pattern=[0,1,0,1,0,0,1,1], payload_length=80):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.byte],#in_sig=[np.byte]\n            out_sig=[np.byte]\n        )\n        \n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.start_pattern = start_pattern\n        self.start_pattern_length = len(start_pattern)\n        \n        self.payload_length = payload_length\n        \n        # Use a deque for an efficient fixed-size sliding window\n        self.buffer = collections.deque(maxlen=self.start_pattern_length)\n        \n        \n    def work(self, input_items, output_items):\n        # [0,1,0,1,0,0,1,1,0,1,0,0,1,0,0,0,0,1,1,0,0,1,0,1,0,1,1,0,1,1,0,0,0,1,1,0,1,1,0,0,0,1,1,0,1,1,1,1,0,0,1,0,0,0,0,1]\n        # Start message (\"S\"): 0,1,0,1,0,0,1,1\n        sleep_sec = 2\n        \n        data_in = input_items[0]\n        #data_in = data_in[len(data_in)-70:len(data_in)]\n        #print(self.start_pattern)\n        #print(input_items[0][:])\n        \n        print(\"List length: \", len(input_items[0][:]))\n        # Check if any element in the array is equal to the target value\n        if len(input_items[0][:]) >= (self.start_pattern_length + self.payload_length):\n            print(\"Processing ...\")\n            \n            #num_items_search = len(data_in) - (len(data_in) % self.payload_length)\n            #data_in_search = data_in[0:num_items_search]\n            data_in_search = data_in\n            \n            print(\"Had \", len(data_in), \" items. Searching through \", len(data_in_search), \" items.\")\n            for index, item in enumerate(data_in_search):\n                if (len(data_in_search) - index - 1) < self.payload_length:\n                    break\n                \n                self.buffer.append(item)\n                \n                # Check for the start_pattern only when the buffer is full\n                if len(self.buffer) == self.start_pattern_length:\n                    if list(self.buffer) == self.start_pattern:\n                        print(\"Pattern found! Reading the next payload_length items\")\n                        print(index)\n                        print(len(data_in_search))\n                        \n                        extracted_payload = data_in_search[(index + 1):(index + 1 + self.payload_length)]\n                        converted_chars = self.bits_to_chars(extracted_payload)\n                        print(extracted_payload)\n                        print(converted_chars)\n                        \n                        time.sleep(sleep_sec)\n                        return len(output_items[0])\n\n        time.sleep(sleep_sec)\n        \n        return len(output_items[0])\n        \n    def bits_to_chars(self, bit_list):\n        \"\"\"\n        Converts a list of 0s and 1s (bits) into a list of characters.\n        Args: bit_list (list): A list of integers (0 or 1) representing a bit stream.\n        Returns: List: A list of characters.\n        \"\"\"\n        # Ensure the bit list length is a multiple of 8\n        if len(bit_list) % 8 != 0:\n            raise ValueError(\"The bit list must have a length that is a multiple of 8 to form characters.\")\n        \n        char_list = []\n        # Process the bit stream in chunks of 8\n        for i in range(0, len(bit_list), 8):\n            byte_value = 0\n            eight_bits = bit_list[i:i+8]\n            \n            # Convert the 8 bits to a single byte value\n            for j in range(8):\n                byte_value += eight_bits[j] * (2**(7 - j))\n                \n            # Convert the byte value to a character and add to the list\n            char_list.append(chr(byte_value))\n            \n        return char_list\n        \n        \n    "
    payload_length: '80'
    start_pattern: '[0, 1, 0, 1, 0, 0, 1, 1]'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Morse code vector source
      """

      #  epy_block_0.py
      #  revised 09/10/2019 - finish code table
      #  revised 09/11/2019 - test for bad character
      #  revised 09/27/2019 - get input from a Message Edit block (code from Volker Schroer dl1ksv)

      import numpy as np
      from gnuradio import gr

      import pmt

      textboxValue = ""

      Morse = {
        # codes from https://www.itu.int/rec/R-REC-M.1677-1-200910-I/en
      "A": "1,0,0,1,0",
        "B": "0,1,1,0,1",
        "C": "1,1,0,1,0",
        "D": "0,1,0,1,1",
        "E": "1,1,1,0,0",
        "F": "0,0,1,1,1",
        "G": "1,0,1,1,0",
        "H": "0,1,1,1,0",
        "I": "1,1,0,0,1",
        "J": "0,0,1,0,1",
        "K": "1,0,0,0,1", 
        "L": "0,1,0,0,1",
        "M": "1,1,1,0,1",
        "N": "0,0,1,1,0",
        "O": "1,0,1,1,1",
        "P": "0,1,1,0,0",
        "Q": "1,1,0,1,1",
        "R": "0,0,1,0,0",
        "S": "1,0,0,1,1",
        "T": "0,1,0,1,0",
        "U": "1,1,1,1,0",
        "V": "0,0,1,1,0",
        "W": "1,0,1,0,0",
        "X": "0,1,1,1,1",
        "Y": "1,1,0,0,0",
        "Z": "0,0,1,0,1",
        " ": "1,0,1,0,1",
        "?": "0,0,0,0,0",
            }

      class mc_sync_block(gr.sync_block):
          """
          reads input from a message port
          generates a vector of Morse code bits
          """
          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Morse code vector source",
                  in_sig = None,
                  out_sig = [np.byte])
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('clear_input'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              global textboxValue
              textboxValue = pmt.symbol_to_string (msg)
              # print (textboxValue)
          
          def work(self, input_items, output_items):
              global Morse
              global textboxValue
              bit_stream = "1,1,0,1,1,1,0,1,0,1,0,1"
              if (len (textboxValue) > 0):
                  for in0 in textboxValue:
                      # get next char
                      inChar = str (in0)
                      # convert to upper case
                      ch = inChar.upper()
                      # test for character in table
                      if (not(ch in Morse)):
                          print("bad char", ch)
                          ch = "?"        # replace bad character with a '?'
                      # build vector
                      _dots = str (Morse.get(ch))
                      # print (ch, _dots)
                      bit_stream += (","+_dots)    # letter space

                  # bit_stream += ",0,0,0,0," + bit_stream # finish with word space
                  bit_stream += ",0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0"
                  print (bit_stream)

                  # get length of string
                  _len = len(bit_stream)
                  # num of elements = (length+1) / 2
                  _num_elem = int((_len+1) / 2)
                  print(_num_elem)

                  # convert and store elements in output array
                  for x in range (_len):
                      y = int(x / 2)
                      if (bit_stream[x] == '1'):
                          output_items[0][y] = 1
                      elif (bit_stream[x] == '0'):
                          output_items[0][y] = 0
                      else:
                          continue    # skip commas

                  # clear input line
                  textboxValue = ""
                  # self.message_port_pub(pmt.intern('clear_input'), pmt.intern(''))
              else:
                  _num_elem = 0

              return (_num_elem)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    label: input
    type: string
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Binary Compare"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: Sync Out
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    size: '12000'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_float_to_complex_0, '0']
- [analog_const_source_x_1, '0', blocks_float_to_complex_0, '1']
- [analog_frequency_modulator_fc_0, '0', blocks_add_xx_0, '1']
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_1, '0']
- [analog_frequency_modulator_fc_0, '0', channels_channel_model_0, '0']
- [analog_noise_source_x_1, '0', blocks_throttle2_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [audio_source_0, '0', analog_agc_xx_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_repeat_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', blocks_repeat_1_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_complex_to_real_0, '0', virtual_sink_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_moving_average_xx_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_real_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_repeat_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_repeat_1_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_sub_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_throttle2_1, '0', blocks_add_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_char_to_float_0, '0']
- [blocks_vector_source_x_0, '0', digital_packet_headergenerator_bb_default_0, '0']
- [channels_channel_model_0, '0', blocks_multiply_xx_1, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [digital_packet_headergenerator_bb_default_0, '0', blocks_char_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_repeat_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [epy_block_0, '0', blocks_null_sink_1, '0']
- [epy_block_1, '0', blocks_char_to_float_0, '0']
- [epy_block_1, clear_input, qtgui_edit_box_msg_0, val]
- [qtgui_edit_box_msg_0, msg, epy_block_1, msg_in]
- [virtual_source_0, '0', blocks_float_to_complex_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
