options:
  parameters:
    author: Alex
    generate_options: qt_gui
    id: lab4_part4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: eb_n0_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: fc
    start: '0'
    step: '1'
    stop: 2*symbol_rate
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '76800'
  states: {}
- name: sig_pwr
  id: variable
  parameters:
    value: '2'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: |
      0.5*np.sqrt( sig_pwr/ (10**(eb_n0_db/10)) * samp_rate/symbol_rate )
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: short
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_char_to_short_0_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: short
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 2/np.sqrt(2*symbol_rate)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2/np.sqrt(2*symbol_rate)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/np.sqrt(2)
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/symbol_rate)
    type: float
  states: {}
- name: blocks_short_to_char_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '2048'
    type: byte
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '2048'
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: '20'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: byte
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: int(samp_rate/symbol_rate)
    taps: np.ones((samp_rate//symbol_rate))
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: int(samp_rate/symbol_rate)
    taps: '-1.0*np.ones((samp_rate//symbol_rate))'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: silly_map_0
  id: silly_map
  parameters: {}
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bob
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bob
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle2_1, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_add_xx_1, '0', blocks_short_to_char_0, '0']
- [blocks_char_to_float_0, '0', blocks_repeat_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_short_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_short_0_0, '0', blocks_add_xx_1, '0']
- [blocks_complex_to_float_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_complex_to_float_0, '1', digital_binary_slicer_fb_0, '0']
- [blocks_delay_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_delay_0, '0', blocks_skiphead_0, '0']
- [blocks_delay_0_0, '0', blocks_char_to_float_1, '0']
- [blocks_delay_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_vxx_1_0, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_2, '0', qtgui_const_sink_x_1, '0']
- [blocks_pack_k_bits_bb_0, '0', fec_ber_bf_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', fec_ber_bf_0, '1']
- [blocks_pack_k_bits_bb_1, '0', blocks_char_to_float_0, '0']
- [blocks_pack_k_bits_bb_1, '0', blocks_delay_0, '0']
- [blocks_repeat_0, '0', silly_map_0, '0']
- [blocks_short_to_char_0, '0', blocks_delay_0_0, '0']
- [blocks_skiphead_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_skiphead_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_sub_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle2_1, '0', blocks_add_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_skiphead_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_short_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_char_to_short_0, '0']
- [digital_glfsr_source_x_0, '0', blocks_pack_k_bits_bb_1, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [silly_map_0, '0', blocks_multiply_const_vxx_2, '0']
- [virtual_source_0, '0', fir_filter_xxx_0, '0']
- [virtual_source_0, '0', fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
