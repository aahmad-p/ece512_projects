options:
  parameters:
    generate_options: hb
    id: silly_map
    output_language: python
    title: silly_map
  states: {}

blocks:
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: '2'
    type: float
  states: {}
- name: analog_const_source_x_0_2
  id: analog_const_source_x
  parameters:
    const: '3'
    type: float
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_2
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.49'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.49'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '0.49'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_2
  id: blocks_add_const_vxx
  parameters:
    const: '0.49'
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0_2
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_2
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_0_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_0_1
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_0_2
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_1
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_2
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_3
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_3_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_3_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_4
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_4_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_4_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_4_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_3
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sub_xx_1, '1']
- [analog_const_source_x_0_0, '0', blocks_sub_xx_1_0, '1']
- [analog_const_source_x_0_1, '0', blocks_sub_xx_1_1, '1']
- [analog_const_source_x_0_2, '0', blocks_sub_xx_1_2, '1']
- [blocks_abs_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_abs_xx_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_abs_xx_0_1, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_abs_xx_0_2, '0', blocks_multiply_const_vxx_0_3, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_int_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_float_to_int_0_0, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_float_to_int_0_1, '0']
- [blocks_add_const_vxx_0_2, '0', blocks_float_to_int_0_2, '0']
- [blocks_add_const_vxx_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_const_vxx_1_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_add_const_vxx_1_0_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_add_const_vxx_1_0_2, '0', blocks_multiply_const_vxx_0_0_2, '0']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_add_xx_0, '3']
- [blocks_float_to_complex_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_float_to_complex_0_0_1, '0', blocks_add_xx_0, '1']
- [blocks_float_to_complex_0_0_2, '0', blocks_add_xx_0, '0']
- [blocks_float_to_int_0, '0', blocks_int_to_float_0, '0']
- [blocks_float_to_int_0_0, '0', blocks_int_to_float_0_0, '0']
- [blocks_float_to_int_0_1, '0', blocks_int_to_float_0_1, '0']
- [blocks_float_to_int_0_2, '0', blocks_int_to_float_0_2, '0']
- [blocks_int_to_float_0, '0', blocks_add_const_vxx_1_0, '0']
- [blocks_int_to_float_0_0, '0', blocks_add_const_vxx_1_0_0, '0']
- [blocks_int_to_float_0_1, '0', blocks_add_const_vxx_1_0_1, '0']
- [blocks_int_to_float_0_2, '0', blocks_add_const_vxx_1_0_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0_3, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0_4, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_multiply_const_vxx_0_0_3_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_multiply_const_vxx_0_0_4_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_multiply_const_vxx_0_0_3_1, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_multiply_const_vxx_0_0_4_1, '0']
- [blocks_multiply_const_vxx_0_0_2, '0', blocks_multiply_const_vxx_0_0_3_2, '0']
- [blocks_multiply_const_vxx_0_0_2, '0', blocks_multiply_const_vxx_0_0_4_2, '0']
- [blocks_multiply_const_vxx_0_0_3, '0', blocks_float_to_complex_0_0, '1']
- [blocks_multiply_const_vxx_0_0_3_0, '0', blocks_float_to_complex_0_0_0, '1']
- [blocks_multiply_const_vxx_0_0_3_1, '0', blocks_float_to_complex_0_0_1, '1']
- [blocks_multiply_const_vxx_0_0_3_2, '0', blocks_float_to_complex_0_0_2, '1']
- [blocks_multiply_const_vxx_0_0_4, '0', blocks_float_to_complex_0_0, '0']
- [blocks_multiply_const_vxx_0_0_4_0, '0', blocks_float_to_complex_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_4_1, '0', blocks_float_to_complex_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0_4_2, '0', blocks_float_to_complex_0_0_2, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_0_3, '0', blocks_add_const_vxx_0_2, '0']
- [blocks_sub_xx_1, '0', blocks_abs_xx_0, '0']
- [blocks_sub_xx_1_0, '0', blocks_abs_xx_0_0, '0']
- [blocks_sub_xx_1_1, '0', blocks_abs_xx_0_1, '0']
- [blocks_sub_xx_1_2, '0', blocks_abs_xx_0_2, '0']
- [pad_source_0, '0', blocks_sub_xx_1, '0']
- [pad_source_0, '0', blocks_sub_xx_1_0, '0']
- [pad_source_0, '0', blocks_sub_xx_1_1, '0']
- [pad_source_0, '0', blocks_sub_xx_1_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
